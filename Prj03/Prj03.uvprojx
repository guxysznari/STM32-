# Keil uVision project Prj03.uvprojx, settings and files
target Prj03 (ARM-ADS)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Prj03 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL
  c include: .\f01_System\inc;.\f01_System\inc_core;.\f03_STM32F4_HAL_Library\Inc;.\f03_STM32F4_HAL_Library\Inc\Legacy;.\f04_User\inc;.\f05_Bsp\B0_Components;.\f05_Bsp\B0_Components\stmpe1600;.\f05_Bsp\B1_System;.\f05_Bsp\B2_Usmart;.\f05_Bsp\B3_Malloc;.\f05_Bsp\B4_Lwip\LwIP\src\include;.\f05_Bsp\B4_Lwip\LwIP\system;.\f05_Bsp\B4_Lwip\lwip_app;.\f05_Bsp\B5_Ethernet;.\f05_Bsp\B6_Timer;.\f05_Bsp\B7_Can;.\f05_Bsp\B8_SdCard;.\f05_Bsp\B9_Adc;.\f05_Bsp\B10_Rtc;.\f05_Bsp\B11_SdRam;.\f05_Bsp\B13_Stm32_Eval
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group f01_System
    ./f01_System/src/: system_stm32f4xx.c
  group f02_StartUp
    ./f02_StartUp/: startup_stm32f429xx.s
  group f03_STM32F4_HAL_Library
    ./f03_STM32F4_HAL_Library/Src/: stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c
  group f04_User
    ./f04_User/src/: led.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group f05_Bsp
    ./f05_Bsp/B1_System/: mySys.c delay.c usart.c
    ./f05_Bsp/B2_Usmart/: usmart.c usmart_str.c usmart_config.c
    ./f05_Bsp/B3_Malloc/: malloc.c
    ./f05_Bsp/B7_Can/: can.c
    ./f05_Bsp/B8_SdCard/: sdcard_sdio.c
    ./f05_Bsp/B9_Adc/: adc_temperature.c
    ./f05_Bsp/B10_Rtc/: rtc.c
    ./f05_Bsp/B11_SdRam/: sdram.c
  group f05_Bsp\B0_Components
    ./f05_Bsp/B0_Components/stmpe1600/: stmpe1600.c
  group f05_Bsp\B13_Stm32_Eval
    ./f05_Bsp/B13_Stm32_Eval/: stm324x9i_eval.c stm324x9i_eval_io.c
  group f05_Bsp\B4_Lwip\LwIP\src\api
    ./f05_Bsp/B4_Lwip/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
  group f05_Bsp\B4_Lwip\LwIP\src\core\ipv4
    ./f05_Bsp/B4_Lwip/LwIP/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
  group f05_Bsp\B4_Lwip\LwIP\src\core
    ./f05_Bsp/B4_Lwip/LwIP/src/core/: udp.c def.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
  group f05_Bsp\B4_Lwip\LwIP\src\netif
    ./f05_Bsp/B4_Lwip/LwIP/src/netif/: etharp.c
  group f05_Bsp\B4_Lwip\lwip_app
    ./f05_Bsp/B4_Lwip/lwip_app/: tcp_echoclient.c tcp_echoserver.c udp_echoclient.c udp_echoserver.c app_ethernet.c ethernetif.c
